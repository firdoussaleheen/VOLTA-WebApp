** thing **
*
* NI Multisim to SPICE Netlist Export
* Generated by: Boss
* Thu, Feb 05, 2015 20:42:43
*

*## Multisim Component C2 ##*
cC2 2 0 1e-006

*## Multisim Component C1 ##*
cC1 1 0 1e-006

*## Multisim Component V2 ##*
vV2 2 0 dc 12 ac 0 0
+           distof1 0 0
+           distof2 0 0

*## Multisim Component V1 ##*
vV1 1 0 dc 0 ac 1 0
+      distof1 0 0
+      distof2 0 0
+      sin(0 1 1000 0 0 0)
