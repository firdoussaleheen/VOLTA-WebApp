** lab10_sim_ckt1 **
*
* NI Multisim to SPICE Netlist Export
* Generated by: CSNAP-VLA
* Fri, Jan 23, 2015 00:18:40
*

*## Multisim Component V2 ##*
vV2 1 0 dc 1.5 ac 0 0
+           distof1 0 0
+           distof2 0 0

*## Multisim Component V1 ##*
vV1 2 0
+   pulse( 0 5 0 1e-009 1e-009
+   {50*0.01/1000}
+   {1/1000})

*## Multisim Component Q1 ##*
xQ1 3 2 0 2N7000_2__MOS_ENH_N__1

*## Multisim Component L1 ##*
lL1 1 3 0.001

*## Multisim Component R1 ##*
rR1 4 0 1000 vresR1
.model vresR1 r(  )

*## Multisim Component C1 ##*
cC1 4 0 1e-007

*## Multisim Component D1 ##*
dD1 3 4 D1N4001RL/ON__DIODE__1

.SUBCKT 2N7000_2__MOS_ENH_N__1 1 2 3
Cgs  2 3 12.3E-12
Cgd1 2 4 27.4E-12
Cgd2 1 4 6E-12
M1 1 2 3 3 MOST1 W=9.7m L=2u
M2 4 2 1 3 MOST2 W=9.7m L=2u
D1 3 1 Dbody
.MODEL MOST1 NMOS(Level=3 Kp=20.78u W=9.7m L=2u Rs=20m Vto=2 Rd=1.186)
.MODEL MOST2 NMOS(VTO=-4.73 Kp=20.78u W=9.7m L=2u Rs=20m)
.MODEL Dbody D(Is=125f N=1.023 Rs=1.281 Ikf=18.01 Cjo=46.3p M=.3423
+            Vj=.4519 Bv=60 Ibv=10u Tt=161.6n)
.ENDS

**************************************
*      Model Generated by MODPEX     *
*Copyright(c) Symmetry Design Systems*
*         All Rights Reserved        *
*    UNPUBLISHED LICENSED SOFTWARE   *
*   Contains Proprietary Information *
*      Which is The Property of      *
*     SYMMETRY OR ITS LICENSORS      *
*    Modeling services provided by   *
* Interface Technologies www.i-t.com *
**************************************
.MODEL D1N4001RL/ON__DIODE__1 d
+IS=1.22478e-08 RS=0.0414786 N=1.83369 EG=0.6
+XTI=0.05 BV=50 IBV=5e-08 CJO=1e-11
+VJ=0.7 M=0.5 FC=0.5 TT=1e-09
+KF=0 AF=1
* Model generated on October 12, 2003
* Model format: PSpice
