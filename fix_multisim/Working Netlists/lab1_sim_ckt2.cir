** lab1_sim_ckt2 **
*
* NI Multisim to SPICE Netlist Export
* Generated by: CSNAP-VLA
* Thu, Jan 22, 2015 20:10:39
*

*## Multisim Component V1 ##*
vV1 Vdc 0 dc 10 ac 0 0
+           distof1 0 0
+           distof2 0 0

*## Multisim Component C1 ##*
cC1 Vc 0 1e-006

*## Multisim Component R1 ##*
rR1 Vdc Vc 1000 vresR1
.model vresR1 r(  )
