** lab6_sim_ckt1 **
*
* NI Multisim to SPICE Netlist Export
* Generated by: CSNAP-VLA
* Thu, Jan 22, 2015 23:22:55
*

*## Multisim Component R1 ##*
rR1 Vout 0 100 vresR1
.model vresR1 r(  )

*## Multisim Component L1 ##*
lL1 Vin Vout 0.001

*## Multisim Component V1 ##*
vV1 Vin 0 dc 0 ac 1 0
+      distof1 0 0
+      distof2 0 0
+      sin(0 {0.707*1.414213562} 100 0 0 0)
