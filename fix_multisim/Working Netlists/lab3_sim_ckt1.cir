** lab3_sim_ckt1 **
*
* NI Multisim to SPICE Netlist Export
* Generated by: CSNAP-VLA
* Thu, Jan 22, 2015 20:53:30
*

*## Multisim Component V1 ##*
vV1 Vac 0 dc 0 ac 1 0
+      distof1 0 0
+      distof2 0 0
+      sin(0 {0.707*1.414213562} 60 0 0 0)

*## Multisim Component C1 ##*
cC1 Vc 0 1e-006

*## Multisim Component R1 ##*
rR1 Vac Vc 1000 vresR1
.model vresR1 r(  )
