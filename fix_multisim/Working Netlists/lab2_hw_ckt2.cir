** lab2_hw_ckt2 **
*
* NI Multisim to SPICE Netlist Export
* Generated by: CSNAP-VLA
* Thu, Jan 22, 2015 20:37:27
*

*## Multisim Component C1 ##*
cC1 Vc 0 1e-007

*## Multisim Component R1 ##*
rR1 Vpulse Vc 1000 vresR1
.model vresR1 r(  )

*## Multisim Component V1 ##*
vV1 Vpulse 0
+   pulse( 0 1 0 1e-009 1e-009
+   {50*0.01/50}
+   {1/50})
