** Design5 **
*
* NI Multisim to SPICE Netlist Export
* Generated by: User
* Thu, Jul 07, 2016 11:50:36
*

*## Multisim Component R1 ##*
rR1 2 0 10 vresR1
.model vresR1 r(  )

*## Multisim Component C1 ##*
cC1 2 0 1e-006

*## Multisim Component L1 ##*
lL1 1 2 0.001

*## Multisim Component V1 ##*
vV1 1 0
+   pulse( 0 1 0 1e-009 1e-009
+   {50*0.01/1000}
+   {1/1000})
