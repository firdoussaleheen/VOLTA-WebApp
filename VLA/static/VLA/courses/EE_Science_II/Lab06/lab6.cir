** Design5 **
*
* NI Multisim to SPICE Netlist Export
* Generated by: User
* Wed, Aug 12, 2015 12:23:29
*

*## Multisim Component R1 ##*
rR1 0 2 1000 vresR1
.model vresR1 r(  )

*## Multisim Component C1 ##*
cC1 2 0 1e-006

*## Multisim Component L1 ##*
lL1 1 2 0.001

*## Multisim Component V1 ##*
vV1 1 0 dc 1 ac 0 0
+           distof1 0 0
+           distof2 0 0
