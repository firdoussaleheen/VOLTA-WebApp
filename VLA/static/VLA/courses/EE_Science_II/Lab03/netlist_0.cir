** 2 **
*
* NI Multisim to SPICE Netlist Export
* Generated by: User
* Sun, Jul 03, 2016 20:40:16
*

*## Multisim Component V1 ##*
vV1 1 0 dc 0 ac 1 0
+      distof1 0 0
+      distof2 0 0
+      sin(0 1 10 0 0 0)

*## Multisim Component C1 ##*
cC1 2 0 1e-006

*## Multisim Component R1 ##*
rR1 1 2 1000 vresR1
.model vresR1 r(  )
