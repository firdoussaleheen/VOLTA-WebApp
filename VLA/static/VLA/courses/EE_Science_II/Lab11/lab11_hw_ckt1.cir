** lab11_hw_ckt1 **
*
* NI Multisim to SPICE Netlist Export
* Generated by: CSNAP-VLA
* Fri, Jan 23, 2015 00:26:21
*

*## Multisim Component V1 ##*
vV1 3 0 dc 0 ac 1 0
+      distof1 0 0
+      distof2 0 0
+      sin(0 {0.707*1.414213562} 60 0 0 0)

*## Multisim Component R1 ##*
rR1 4 0 1000 vresR1
.model vresR1 r(  )

*## Multisim Component C1 ##*
cC1 4 0 1e-007

*## Multisim Component D1 ##*
dD1 3 4 D1N4001RL/ON__DIODE__1

**************************************
*      Model Generated by MODPEX     *
*Copyright(c) Symmetry Design Systems*
*         All Rights Reserved        *
*    UNPUBLISHED LICENSED SOFTWARE   *
*   Contains Proprietary Information *
*      Which is The Property of      *
*     SYMMETRY OR ITS LICENSORS      *
*    Modeling services provided by   *
* Interface Technologies www.i-t.com *
**************************************
.MODEL D1N4001RL/ON__DIODE__1 d
+IS=1.22478e-08 RS=0.0414786 N=1.83369 EG=0.6
+XTI=0.05 BV=50 IBV=5e-08 CJO=1e-11
+VJ=0.7 M=0.5 FC=0.5 TT=1e-09
+KF=0 AF=1
* Model generated on October 12, 2003
* Model format: PSpice
