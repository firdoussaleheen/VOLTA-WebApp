** 2 **
*
* NI Multisim to SPICE Netlist Export
* Generated by: User
* Sun, Jul 03, 2016 20:42:59
*

*## Multisim Component V1 ##*
vV1 1 0
+   pulse( 0 5 0 1e-009 1e-009
+   {50*0.01/2000}
+   {1/2000})

*## Multisim Component L1 ##*
lL1 2 3 0.001

*## Multisim Component C1 ##*
cC1 3 0 4.7e-009

*## Multisim Component R1 ##*
rR1 1 2 1500 vresR1
.model vresR1 r(  )
