** lab5_hw_ckt2 **
*
* NI Multisim to SPICE Netlist Export
* Generated by: CSNAP-VLA
* Thu, Jan 22, 2015 22:45:57
*

*## Multisim Component V1 ##*
vV1 1 0 dc 0 ac 1 0
+      distof1 0 0
+      distof2 0 0
+      sin(0 {0.707*1.414213562} 1000 0 0 0)

*## Multisim Component L1 ##*
lL1 V2 Vc 0.001

*## Multisim Component C1 ##*
cC1 Vc 0 4.7e-009

*## Multisim Component R1 ##*
rR1 1 V2 100 vresR1
.model vresR1 r(  )
