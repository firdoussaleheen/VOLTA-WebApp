** lab4_hw_ckt2 **
*
* NI Multisim to SPICE Netlist Export
* Generated by: CSNAP-VLA
* Thu, Jan 22, 2015 22:19:53
*

*## Multisim Component L1 ##*
lL1 V2 Vc 0.001

*## Multisim Component C1 ##*
cC1 Vc 0 4.7e-009

*## Multisim Component R1 ##*
rR1 Vpulse V2 1500 vresR1
.model vresR1 r(  )

*## Multisim Component V1 ##*
vV1 Vpulse 0
+   pulse( 0 1 0 1e-009 1e-009
+   {50*0.01/1000}
+   {1/1000})
