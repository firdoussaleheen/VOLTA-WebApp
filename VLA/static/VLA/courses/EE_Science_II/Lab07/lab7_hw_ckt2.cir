** lab6_hw_ckt2 **
*
* NI Multisim to SPICE Netlist Export
* Generated by: CSNAP-VLA
* Thu, Jan 22, 2015 23:19:48
*

*## Multisim Component C1 ##*
cC1 1 2 1e-007

*## Multisim Component R1 ##*
rR1 2 0 100 vresR1
.model vresR1 r(  )

*## Multisim Component V1 ##*
vV1 1 0 dc 0 ac 1 0
+      distof1 0 0
+      distof2 0 0
+      sin(0 {0.707*1.414213562} 100 0 0 0)
