** Design1 **
*
* NI Multisim to SPICE Netlist Export
* Generated by: User
* Tue, Sep 15, 2015 15:11:51
*

*## Multisim Component C1 ##*
cC1 1 2 1e-007

*## Multisim Component V1 ##*
vV1 1 0 dc 0 ac 1 0
+      distof1 0 0
+      distof2 0 0
+      sin(0 1 100 0 0 0)

*## Multisim Component R1 ##*
rR1 2 0 100 vresR1
.model vresR1 r(  )
