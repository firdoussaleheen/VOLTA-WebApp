** 2 **
*
* NI Multisim to SPICE Netlist Export
* Generated by: User
* Tue, Sep 15, 2015 14:22:17
*

*## Multisim Component V1 ##*
vV1 2 0
+   pulse( 0 1 0 1e-009 1e-009
+   {50*0.01/50}
+   {1/50})

*## Multisim Component C1 ##*
cC1 3 0 1e-006

*## Multisim Component R1 ##*
rR1 2 3 1000 vresR1
.model vresR1 r(  )
