** 1 **
*
* NI Multisim to SPICE Netlist Export
* Generated by: User
* Sun, Jul 03, 2016 20:36:46
*

*## Multisim Component C1 ##*
cC1 3 0 1e-006

*## Multisim Component R1 ##*
rR1 1 3 100 vresR1
.model vresR1 r(  )

*## Multisim Component V1 ##*
vV1 1 0 dc 10 ac 0 0
+           distof1 0 0
+           distof2 0 0
